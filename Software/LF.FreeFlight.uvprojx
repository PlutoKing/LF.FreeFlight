# Keil uVision project LF.FreeFlight.uvprojx, settings and files
target FreeFlight (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LF.FreeFlight
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\STM32\core;.\STM32\lib\inc;.\STM32\sys;.\Project;.\Project\Algorithm;.\Project\Hardware;.\Project\Function;.\Project\Service
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Function
    ./Project/: main.c
    ./Project/Function/: task.c
  group Service
    ./Project/Service/: lflink.c
  group Hardware
    ./Project/Hardware/: led.c usart1.c iic1.c mpu9250.c
  group System
    ./STM32/sys/: delay.c stm32f4xx_it.c system_stm32f4xx.c
  group Core
    ./STM32/core/: startup_stm32f40_41xxx.s
  group Library
    ./STM32/lib/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c
